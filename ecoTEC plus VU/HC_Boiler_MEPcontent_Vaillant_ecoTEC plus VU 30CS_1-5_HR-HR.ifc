Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-04-06T09:57:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 06 09:57:12 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{91D44130-C5C5-40A3-892D-4483BAD21D16}\ifc * Database version: 5507 * Database creation date: Mon Apr 06 09:57:09 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Apr 06 09:57:10 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 06 09:57:10 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: ecoTEC plus VU 30CS/1-5, HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR:ecoTEC plus VU 30CS/1-5:1395621
In: V00
Type - Material: Color RGB 121-121-121, Color RGB 153-255-051, Color RGB 244-244-244, Color RGB 040-040-040
Type - Dimensions - Air Supply Connection Diameter: 100 mm; Depth: 348 mm; Drain Connection Diameter: 25.4 mm; Flue Gas Connection Diameter: 60 mm; Gas Connection Diameter: 20 mm; Height: 720 mm; Hydronic Connection Diameter: 19 mm; Hydronic Return2: 19 mm; Hydronic Supply2: 19 mm; Use Nominal Diameter: yes; Width: 440 mm
Type - Electrical - Loads - Voltage: 230 V
Type - Identity Data - Article Description: kondenzacijski bojler; Article Type: ecoTEC plus VU 30CS/1-5; Base Family Version: 12.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: kondenzacijski bojler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.12; Manufacturer: Vaillant; Manufacturer Art. No.: 0010024586; Manufacturer URL: https://www.vaillant.hr/poslovni-partneri/; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoTEC plus VU 30CS/1-5; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoTEC plus; Revit Version: 2018; Type Name: ecoTEC plus VU 30CS/1-5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Green: Color RGB 153-255-051; Grey: Color RGB 121-121-121; White: Color RGB 244-244-244
Type - Mechanical - Fixture Units Flow: 0 m3/s; Gas Flow: 0 m3/s; Heating Power: 349827
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR
Type - Visibility - Drain Visibility: no
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 2.78211 m2; Volume: 0.107438 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Hydronic Return 2 Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply 2 Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Undefined,Other,Undefined,Power,Sanitary,Hydronic Supply,Hydronic Return
Other - Family: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR: ecoTEC plus VU 30CS/1-5; Family and Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR: ecoTEC plus VU 30CS/1-5; Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR: ecoTEC plus VU 30CS/1-5; Type Id: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus_VC_CS_HR-HR: ecoTEC plus VU 30CS/1-5
Phasing - Phase Created: 3. New Construction
Visibility - Show Service Area: no
