Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2019-05-24T10:20:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 24 10:20:36 2019 * Host: B3ROBRAWR2791 * Database: C:\Users\CS\AppData\Local\Temp\{7F9371B2-49E4-486B-93A1-729E89BA19E7}\ifc * Database version: 5507 * Database creation date: Fri May 24 10:20:33 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri May 24 10:20:33 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 24 10:20:33 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: ecoTEC plus VU 486/5-5, HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR:ecoTEC plus VU 486/5-5:1297429
In: V00
Type - Material: Color RGB 116-051-029, Color RGB 244-244-244, Color RGB 121-121-121
Type - Dimensions - Air Supply Connection Diameter: 125 mm; Depth: 405 mm; Drain Connection Diameter: 32 mm; Gas Connection Diameter: 25.4 mm; Height: 720 mm; Hydronic Connection Diameter: 38.1 mm; Use Nominal Diameter: yes; Width: 440 mm
Type - Electrical - Loads - Power: 0 W; Voltage: 230 V
Type - Identity Data - Article Type: ecoTEC plus VU 486/5-5; Base Family Version: 12.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Plinski kondenzacijski bojler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.02; Manufacturer: Vaillant; Manufacturer URL: lhttps://www.vaillant.hr/krajnji-korisnici/proizvodi/ecotec-plus-vu-486-656-46976.html; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoTEC plus VU 486/5-5; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: ecoTEC plus VU 486/5-5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Loads - Radiation: 44000 W
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR
Type - Text - Article Description: Plinski kondenzacijski bojler; Manufacturer Art. No.: 0010021530; Product Line: ecoTEC plus
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 3.12728 m2; Volume: 0.12274 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Drain Fixture Units: 0; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Undefined,Sanitary,Power,Hydronic Supply,Undefined,Hydronic Return
Other - Family: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR: ecoTEC plus VU 486/5-5; Family and Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR: ecoTEC plus VU 486/5-5; Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR: ecoTEC plus VU 486/5-5; Type Id: HC_Boiler_MEPcontent_Vaillant_ecoTEC plus 406-476-636_HR-HR: ecoTEC plus VU 486/5-5
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Show Service Space: no
