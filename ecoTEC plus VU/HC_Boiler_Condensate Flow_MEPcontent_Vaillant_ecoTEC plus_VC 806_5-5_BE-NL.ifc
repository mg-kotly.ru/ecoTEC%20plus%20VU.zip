Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-08-30T18:21:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 30 18:21:31 2018 * Host: B3ROBRAWR3854 * Database: C:\Users\GB\AppData\Local\Temp\{73D1913D-9AC3-4C31-BD3E-4D66F80A3357}\ifc * Database version: 5507 * Database creation date: Thu Aug 30 18:21:29 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Aug 30 18:21:30 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 30 18:21:30 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: VC 806/5-5, HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL:VC 806/5-5:1442553
In: V00
Type - Material: Color RGB 121-121-121, Color RGB 244-244-244, Color RGB 116-051-029
Type - Dimensions - Condensate Connection: 32 mm; Depth: 602 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 160 mm; Gas Diameter: 25.4 mm; Height: 960 mm; Hydronic Return Diameter: 31.8 mm; Hydronic Supply Diameter: 31.8 mm; Supply Air Diameter: 110 mm; Use Nominal Diameter: yes; Width: 480 mm
Type - Electrical - Loads - Voltage: 230.002 V
Type - Identity Data - Article Description: Condensatiegasketel; Article Type: ecoTEC plus VC 806; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Condensatiegasketel; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 11.16; GLN: 4024074000007; Manufacturer: Vaillant; Manufacturer Art. No.: 0010010760; Manufacturer URL: http://www.vaillant.be; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoTEC plus VC 806; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoTEC plus; Revit Version: 2018; Type Name: VC 806/5-5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Connection Pipes: Color RGB 116-051-029; Grey: Color RGB 121-121-121; White: Color RGB 244-244-244
Type - Mechanical - Tap Capacity at 40°C: 0 m3/s
Type - Mechanical - Flow - Supply Air Flow: 0 m3/s
Type - Mechanical - Loads - Radiation: 74700 W
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL
Type - Text - Base Family Version: 11.19
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 5.75605 m2; Volume: 1.93163 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Return,Power,Hydronic Supply,Undefined,Supply Air,Sanitary
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL: VC 806/5-5; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL: VC 806/5-5; Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL: VC 806/5-5; Type Id: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoTEC plus_VC 806-1206_BE-NL: VC 806/5-5
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Show Service Area: no
